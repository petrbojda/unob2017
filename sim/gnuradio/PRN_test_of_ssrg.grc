<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ssrg_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>feedback</value></param>
<param><key>value</key><value>[0,1,0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>init_register</value></param>
<param><key>value</key><value>[1,1,1,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20000000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>chiprate_generator_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>freq</key><value>chip_rate</value></param>
<param><key>offset</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>prn_ssrg_ff</key>
<param><key>id</key><value>prn_ssrg_ff_0</value></param>
<param><key>ampl</key><value>2</value></param>
<param><key>fb_reg</key><value>feedback</value></param>
<param><key>init_reg</key><value>init_register</value></param>
<param><key>offset</key><value>-1</value></param>
</block>
<block>
<key>prn_ssrg_ff</key>
<param><key>id</key><value>prn_ssrg_ff_1</value></param>
<param><key>ampl</key><value>2</value></param>
<param><key>fb_reg</key><value>feedback</value></param>
<param><key>init_reg</key><value>[1,0,0,0]</value></param>
<param><key>offset</key><value>-1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>ssrg_0, init[1111]</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>clock</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>ssrg_1,init[1000]</value></param>
<param><key>name</key><value>SSRG test</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.3</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>prn_ssrg_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chiprate_generator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chiprate_generator_0</source_block_id><sink_block_id>prn_ssrg_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chiprate_generator_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>prn_ssrg_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>prn_ssrg_ff_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
